# Repository ExplodingLemur/ezusb-logicanalyzer

File README.md:

This is a buffer input board to be used with an LCSoft Cypress FX2 EZ-USB dev board.
Using Sigrok's fx2lafw firmware, this board can be used as a streaming logic analyzer.

http://sigrok.org/wiki/Lcsoft_Mini_Board
http://sigrok.org/wiki/Fx2lafw

## KiCad design cypress_logic_analyzer.kicad_pcb

Parts:
C1: .1uF; C_0805_HandSoldering
P1, P2: CONN_02X10; Pin_Header_Straight_2x10
P3: CONN_01X09; Pin_Header_Angled_1x09
R1, R2, R3, R4, R5, R6, R7, R8: 100; R_0805_HandSoldering
U1: 74LCX245; SOIC-20_7.5x12.8mm_Pitch1.27mm

Connections:
/PB0: P1.15, U1.9 (A7)
/PB1: P1.16, U1.8 (A6)
/PB2: P1.17, U1.7 (A5)
/PB3: P1.18, U1.6 (A4)
/PB4: P2.20, U1.5 (A3)
/PB5: P2.19, U1.4 (A2)
/PB6: P2.18, U1.3 (A1)
/PB7: P2.17, U1.2 (A0)
GND: P1.4, P1.6, P1.9, P1.10, P1.11, P3.9, U1.1 (A->B), U1.10 (GND), U1.19 (CE)
unnamed: P3.1, R1.2
unnamed: P3.2, R2.2
unnamed: P3.3, R3.2
unnamed: P3.4, R4.2
unnamed: P3.5, R5.2
unnamed: P3.6, R6.2
unnamed: P3.7, R7.2
unnamed: P3.8, R8.2
unnamed: R1.1, U1.18 (B0)
unnamed: R2.1, U1.17 (B1)
unnamed: R3.1, U1.16 (B2)
unnamed: R4.1, U1.15 (B3)
unnamed: R5.1, U1.14 (B4)
unnamed: R6.1, U1.13 (B5)
unnamed: R7.1, U1.12 (B6)
unnamed: R8.1, U1.11 (B7)
VCC: P1.19, P1.20, U1.20 (VCC)

Board: 2 copper layers, 35.6 x 40.6 mm, 12 parts (0 on the bottom side), 26 nets.

## Commit log

2015-06-06 Rev1.0 board
2015-06-06 Rev1.1, fixed routing, added decoupling cap

Notices in the files:
cypress_logic_analyzer.kicad_pcb:
Creative Commons BY-SA
